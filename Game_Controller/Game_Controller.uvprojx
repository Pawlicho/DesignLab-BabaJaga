# Keil uVision project Game_Controller.uvprojx, settings and files
target Game_Controller (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MKL05Z32xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.0
  cpu: IRAM(0x1FFFFC00,0x00001000) IROM(0x00000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Game_Controller
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x1ffffc00 size 0x1000
  group src
    ./: i2c.c lcd1602.c main.c uart0.c UART_abs.c gameSettings.c
  group inc
    ./: i2c.h frdm_bsp.h lcd1602.h uart0.h UART_abs.h gameSettings.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
